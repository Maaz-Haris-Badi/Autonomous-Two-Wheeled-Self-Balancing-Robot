<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LAB10.ewp</path>
  </project>
  <batchBuild />
</workspace>
